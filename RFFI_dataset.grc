options:
  parameters:
    generate_options: qt_gui
    id: only_CFO_database
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: SNRdB
  id: variable
  parameters:
    value: '-5'
  states: {}
- name: bw
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '868000000'
  states: {}
- name: clk_offset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: cr
  id: variable
  parameters:
    value: '0'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: pay_len
  id: variable
  parameters:
    value: '255'
  states: {}
- name: preamble_len
  id: variable
  parameters:
    value: '12'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: soft_decoding
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: sync_word
  id: variable
  parameters:
    value: '18'
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/jahnavi/BTP/final_test.bin
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\nclass blk(gr.sync_block):\n    \"\"\"Coarse CFO Estimator (No Compensation)\"\"\"\n\n    def __init__(self, samp_rate=250e3):\n        gr.sync_block.__init__(self,\n            name=\"Coarse CFO Estimator\",\n            in_sig=[np.complex64],  # Input: Complex IQ samples\n            out_sig=[np.float32]  # Output: CFO Estimate (only)\n        )\n        self.samp_rate = samp_rate  # Sampling rate\n\n    def work(self, input_items, output_items):\n        r_n = input_items[0]  # Received signal\n        L = len(r_n)\n        Ts = 1 / self.samp_rate  # Sampling period\n\n        # Compute Coarse CFO\n        freqs = np.fft.fftfreq(L, Ts)\n        delta_f_coarse = np.mean(freqs)  # Coarse CFO Estimate\n\n        output_items[0][:] = delta_f_coarse  # CFO Estimate only (No compensation applied)\n\n        return len(output_items[0])\n\n"
    samp_rate: '250000.0'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\nclass blk(gr.sync_block):\n    \"\"\"Fine CFO Estimator (No Compensation)\"\"\"\n\n    def __init__(self, samp_rate=250e3, preamble_length=128):\n        gr.sync_block.__init__(self,\n            name=\"Fine CFO Estimator\",\n            in_sig=[np.complex64, np.float32],  # Inputs: Raw Signal, Coarse CFO\n            out_sig=[np.float32]  # Output: Fine CFO Estimate (only)\n        )\n        self.samp_rate = samp_rate\n        self.L = preamble_length  # Length of repeating preamble\n\n    def work(self, input_items, output_items):\n        r_n = input_items[0]  # Received signal\n        L = self.L\n        Ts = 1 / self.samp_rate\n\n        # Fine CFO Estimation\n        phase_diff = np.angle(np.sum(r_n[:-L] * np.conj(r_n[L:])))\n        delta_f_fine = -phase_diff / (2 * np.pi * Ts * L)\n\n        output_items[0][:] = delta_f_fine  # Fine CFO Estimate only (No compensation applied)\n\n        return len(output_items[0])\n\n"
    preamble_length: '128'
    samp_rate: '250000.0'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: "import json\nimport os\nimport numpy as np\nimport time\nfrom gnuradio import gr\n\nclass CFODatabaseUpdater(gr.sync_block):\n    def __init__(self, db_path=\"cfo_database.json\", device_id=\"Device_1\"):\n        gr.sync_block.__init__(self, name=\"CFO Database Updater\",\n                               in_sig=[np.float32, np.float32],  # Two real-valued inputs: Coarse CFO, Fine CFO\n                               out_sig=None)\n        self.db_path = db_path\n        self.device_id = device_id  # Allow dynamic device ID\n        self.cfo_database = self.load_database()\n        self.last_warning_time = 0  # Track last warning message\n\n    def load_database(self):\n        \"\"\"Load the CFO database or create a new one if missing/corrupted.\"\"\"\n        if not os.path.exists(self.db_path) or os.stat(self.db_path).st_size == 0:\n            print(\"Warning: CFO database file is missing or empty. Initializing new JSON file.\")\n            self.save_database({})  # Initialize empty database\n            return {}\n\n        try:\n            with open(self.db_path, 'r') as f:\n                return json.load(f)  # Load existing JSON\n        except (json.JSONDecodeError, ValueError):\n            print(\"Error: Invalid JSON format. Resetting database.\")\n            self.save_database({})  # Reset to empty JSON\n            return {}\n\n    def save_database(self, database):\n        \"\"\"Save CFO database to JSON file using atomic writes to prevent corruption.\"\"\"\n        try:\n            temp_path = self.db_path + \".tmp\"\n            with open(temp_path, 'w') as f:\n                json.dump(database, f, indent=4)\n            os.replace(temp_path, self.db_path)  # Atomic rename ensures safe write\n        except IOError as e:\n            print(f\"Error: Failed to save CFO database! {e}\")\n\n    def update_database(self, device_id, coarse_cfo, fine_cfo):\n        \"\"\"Update the CFO database with min, max, mean, and range for each device.\"\"\"\n        coarse_cfo = float(coarse_cfo)  # Convert np.float32 to Python float\n        fine_cfo = float(fine_cfo)      # Convert np.float32 to Python float\n\n        total_cfo = coarse_cfo + fine_cfo  # Compute total estimated CFO\n\n        # ✅ Skip invalid CFO values (but print warning only every 5 sec)\n        if np.isnan(total_cfo) or total_cfo == 0.0:\n            if time.time() - self.last_warning_time > 5:\n                print(f\"Warning: Invalid CFO value (coarse: {coarse_cfo}, fine: {fine_cfo}) detected. Skipping update.\")\n                self.last_warning_time = time.time()\n            return\n\n        # ✅ Ensure valid data structure with default values\n        if device_id in self.cfo_database:\n            cfo_kmin, cfo_kmax, _, _ = self.cfo_database[device_id]\n            cfo_kmin = min(cfo_kmin, total_cfo)\n            cfo_kmax = max(cfo_kmax, total_cfo)\n        else:\n            cfo_kmin = cfo_kmax = total_cfo  # Initialize if new device\n\n        # ✅ Compute mean CFO and range\n        cfo_k = (cfo_kmax + cfo_kmin) / 2\n        lambda_k = (cfo_kmax - cfo_kmin) / 2\n\n        # ✅ Store in CFO database\n        self.cfo_database[device_id] = [\n            float(cfo_kmin), float(cfo_kmax), float(cfo_k), float(lambda_k)\n        ]\n\n        # ✅ Save database only if changes occurred\n        self.save_database(self.cfo_database)\n\n    def work(self, input_items, output_items):\n        \"\"\"Receives CFO estimates and updates the database.\"\"\"\n        if len(input_items[0]) == 0 or len(input_items[1]) == 0:\n            if time.time() - self.last_warning_time > 5:\n                print(\"Warning: No valid CFO values received. Skipping update.\")\n                self.last_warning_time = time.time()\n            return 0  # Skip processing if inputs are missing\n\n        coarse_cfo = float(input_items[0][0])  # Get coarse CFO\n        fine_cfo = float(input_items[1][0])    # Get fine CFO\n\n        self.update_database(self.device_id, coarse_cfo, fine_cfo)\n        return len(input_items[0])\n\n"
    db_path: ' r"/home/jahnavi/BTP/cfo_database1.json"'
    device_id: '1'
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\nclass blk(gr.sync_block):\n    \"\"\"CFO Compensation Block\"\"\"\n\n    def __init__(self, samp_rate=250e3):\n        gr.sync_block.__init__(self,\n            name=\"CFO Compensation\",\n            in_sig=[np.complex64, np.float32, np.float32],  # Inputs: Raw Signal, Coarse CFO, Fine CFO\n            out_sig=[np.complex64]  # Output: CFO Compensated Signal\n        )\n        self.samp_rate = samp_rate  # Sampling rate\n\n    def work(self, input_items, output_items):\n        r_n = input_items[0]  # Received signal\n        delta_f_coarse = input_items[1][0]  # Coarse CFO estimate\n        delta_f_fine = input_items[2][0]  # Fine CFO estimate\n\n        # Compute total estimated CFO\n        delta_f_total = delta_f_coarse + delta_f_fine\n        Ts = 1 / self.samp_rate  # Sampling period\n        n = np.arange(len(r_n))\n        \n        # Apply CFO Compensation\n        correction = np.exp(-1j * 2 * np.pi * delta_f_total * n * Ts)\n        r_compensated = r_n * correction\n        \n        output_items[0][:] = r_compensated  # CFO Compensated Signal\n        \n        return len(output_items[0])\n\n"
    samp_rate: samp_rate
  states: {}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\nclass IQNormalization(gr.sync_block):\n    \"\"\"Block for Normalizing IQ Samples after CFO Compensation\"\"\"\n\n    def __init__(self):\n        gr.sync_block.__init__(self,\n            name=\"IQ Normalization\",\n            in_sig=[np.complex64],  # Input: Compensated IQ samples\n            out_sig=[np.complex64]  # Output: Normalized IQ samples\n        )\n\n    def work(self, input_items, output_items):\n        r_compensated = input_items[0]  # CFO compensated signal\n\n        # Compute Root Mean Square (RMS) of the compensated signal\n        xrms = np.sqrt(np.mean(np.abs(r_compensated) ** 2))\n\n        # Normalize the signal\n        if xrms > 0:\n            s_normalized = r_compensated / xrms\n        else:\n            s_normalized = r_compensated  # Avoid division by zero\n\n        output_items[0][:] = s_normalized\n\n        return len(output_items[0])\n\n"
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: bw
    center_freq0: center_freq
    rx_agc0: Enabled
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_throttle2_0, '0', epy_block_0, '0']
- [blocks_throttle2_0, '0', epy_block_1, '0']
- [blocks_throttle2_0, '0', epy_block_3, '0']
- [epy_block_0, '0', epy_block_1, '1']
- [epy_block_0, '0', epy_block_2, '0']
- [epy_block_0, '0', epy_block_3, '1']
- [epy_block_1, '0', epy_block_2, '1']
- [epy_block_1, '0', epy_block_3, '2']
- [epy_block_3, '0', epy_block_4, '0']
- [epy_block_4, '0', blocks_file_sink_1, '0']
- [uhd_usrp_source_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
